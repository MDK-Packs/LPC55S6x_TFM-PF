# Keil uVision project bl2.uvprojx, settings and files
target LPCXpresso55S69 (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: bl2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314,L6848
  group System Code
    ./: SystemInit.c Driver_Flash.c Driver_USART.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Security:mbed Crypto 3.0.1, TFM Platform:Crypto Keys:Dummy 1.0.0, TFM Platform:NV Counters:Dummy 1.0.0, TFM:Bootloader 1.0.0, TFM Platform:Boot HAL:Platform 1.0.0, TFM Platform:Memory Map 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.5, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:iap1 2.0.1, Device:SDK Drivers:iocon 2.1.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.1.0, Device:SDK Drivers:usart 2.1.1, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.0.0
