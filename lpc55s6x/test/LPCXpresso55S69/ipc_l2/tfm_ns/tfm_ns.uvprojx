# Keil uVision project tfm_ns.uvprojx, settings and files
target LPCXpresso55S69 (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314
  group System Code
    ./: usr_usart0.c
  group CSME_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, TFM:API 1.0.0, TFM:Library:QCBOR 1.0.0, TFM:Library:T_COSE 1.0.0, TFM:Test:Attestation 1.0.0, TFM:Test:Core Positive 1.0.0, TFM:Test:Crypto 1.0.0, TFM:Test:Framework 1.0.0, TFM:Test:IPC 1.0.0, TFM:Test:ITS 1.0.0, TFM:Test:Platform 1.0.0, TFM:Test:QCBOR 1.0.0, TFM:Test:SST 1.0.0, TFM:Test:Secure Client 1.0.0, TFM:Test:T_COSE 1.0.0, CMSIS Driver:USART:flexcomm_usart_cmsis 2.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:dma 2.4.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:usart 2.1.1, Device:SDK Drivers:usart_dma 2.1.1, Device:SDK Project Template:RTE_Device 1.0.0, Device:Startup 1.0.0
