# Keil uVision project tfm_s.uvprojx, settings and files
target LPCXpresso55S69 (6150000::V6.15::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_s
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\TFM\tfm_common_s.sct
  link misc: --import_cmse_lib_out="Objects/tfm_s_CMSE_Lib.o"
--predefine="-include tfm_config.h"
--predefine="-include tfm_config_rte.h"
--predefine="-IRTE/_LPCXpresso55S69/"
--predefine="-IRTE/TFM_Platform/LPC55S69JBD100_cm33_core0/"
--diag_suppress=L6312,L6314,L6329
  group System Code
    ./RTE/Device/LPC55S69JBD100_cm33_core0/: startup_LPC55S69_cm33_core0.S system_LPC55S69_cm33_core0.c
    ./: SystemInit.c Driver_Flash.c Driver_USART.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Security:mbed TLS 2.24.0, TFM Platform:Attest HAL:Template 1.2.0, TFM Platform:Boot Seed:Dummy 1.2.0, TFM Platform:Crypto Keys:Dummy 1.2.0, TFM Platform:Device ID:Dummy 1.2.0, TFM Platform:NV Counters:Dummy 1.2.0, TFM:Core 1.2.0, TFM:Library:QCBOR 1.2.0, TFM:Library:T_COSE 1.2.0, TFM:Secure Service:Crypto 1.2.0, TFM:Secure Service:Initial Attestation 1.2.0, TFM:Secure Service:Internal Trusted Storage 1.2.0, TFM:Secure Service:Platform 1.2.0, TFM:Secure Service:Protected Storage 1.2.0, TFM:Test Service:Core 1.2.0, TFM:Test Service:IPC 1.2.0, TFM:Test Service:IRQ 1.2.0, TFM:Test Service:PS 1.2.0, TFM:Test Service:Secure Client 1.2.0, TFM:Test:Attestation 1.2.0, TFM:Test:Crypto 1.2.0, TFM:Test:Framework 1.2.0, TFM:Test:IPC 1.2.0, TFM:Test:ITS 1.2.0, TFM:Test:PS 1.2.0, TFM:Test:Platform 1.2.0, TFM Platform:Memory Map 1.2.0, TFM Platform:SPM HAL:Platform 1.2.0, TFM Platform:System:Template 1.2.0, TFM Platform:Test:Platform 1.2.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:ctimer 2.2.1, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:i2c 2.1.0, Device:SDK Drivers:iap1 2.1.0, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.2.1, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
