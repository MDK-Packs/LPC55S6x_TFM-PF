# Keil uVision project tfm_ns.uvprojx, settings and files
target LPCXpresso55S69 (6150000::V6.15::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-implicit-function-declaration
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314
  group System Code
    ./: usr_usart0.c
  group CSME_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, TFM:API:Audit Logging 1.2.0, TFM:API:Crypto 1.2.0, TFM:API:Initial Attestation 1.2.0, TFM:API:Internal Trusted Storage 1.2.0, TFM:API:Platform 1.2.0, TFM:API:Protected Storage 1.2.0, TFM:Core 1.2.0, TFM:Library:QCBOR 1.2.0, TFM:Library:T_COSE 1.2.0, TFM:Test:Attestation 1.2.0, TFM:Test:Audit 1.2.0, TFM:Test:Core Positive 1.2.0, TFM:Test:Crypto 1.2.0, TFM:Test:Framework 1.2.0, TFM:Test:ITS 1.2.0, TFM:Test:PS 1.0.0, TFM:Test:Platform 1.2.0, TFM:Test:QCBOR 1.2.0, TFM:Test:Secure Client 1.2.0, TFM:Test:T_COSE 1.2.0, CMSIS Driver:USART:flexcomm_usart_cmsis 2.2.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:dma 2.4.2, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:usart_dma 2.3.1, Device:SDK Project Template:RTE_Device 1.0.0, Device:Startup 1.1.0
